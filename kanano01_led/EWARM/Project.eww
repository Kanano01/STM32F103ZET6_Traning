<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\kanano01_led.ewp</path>
  </project>
  <batchBuild />
</workspace>
